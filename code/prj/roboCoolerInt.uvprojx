# Keil uVision project roboCoolerInt.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: roboCooler
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c include: ..\dev;..\integration;..\lib\stdPeriph;..\lib\stdPeriph\inc;..\src;..\src\timer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Intsrc
    ../integration/: init.cpp init.h main.cpp pushButton_Int.cpp pushButton_Int.h timer_Int.cpp timer_Int.h
  group src
    ../src/timer/: timerDriver.cpp timerDriver.h timer.cpp timer.h
    ../src/: pushButton.cpp pushButton.h pushButtonDriver.cpp pushButtonDriver.h
  group lib
    ../lib/stdPeriph/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c misc.c
    ../lib/stdPeriph/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_tim.h misc.h
  group dev
    ../dev/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f407xx.s stm32f4xx.h stm32f4xx_conf.h stm32f407xx.h system_stm32f4xx.c
