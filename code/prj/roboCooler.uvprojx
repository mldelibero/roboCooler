# Keil uVision project roboCooler.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: roboCooler
  c flags: Optim=1 wLevel=2
  c define: STM32F407xx HSE_VALUE=8000000
  c misc: --exceptions
  c include: ..\dev;..\inc;..\src;..\src\drivers;..\src\leds
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: main.cpp stm32f4xx_it.c init.cpp loop.cpp timer.cpp component.cpp
    ../src/leds/: ledBehavior.cpp ledBehaviorChildren.cpp ledObj.cpp leds.cpp ledStrip.cpp scene.cpp
  group drivers
    ../src/drivers/: ledDriver.cpp ledStripDriver.cpp timerDriver.cpp CDriver.cpp
software components: CMSIS:CORE 5.0.1, Board Support:LED 2.0.0, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:I2C 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:TIM 1.6.0, Device:STM32Cube HAL:UART 1.6.0, Device:STM32Cube HAL:USART 1.6.0, Device:Startup 2.6.0
