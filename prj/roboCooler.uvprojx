# Keil uVision project roboCooler.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: roboCooler
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER
  c misc: --cpp
  c include: ..\inc;..\lib;..\lib\stdPeriph;..\lib\stdPeriph\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group src
    ../src/: init.cpp main.cpp scheduler.cpp
  group lib
    ../lib/: system_stm32f4xx.h startup_stm32f407xx.s system_stm32f4xx.c stm32f4xx.h stm32f4xx_conf.h
  group inc
    ../inc/: init.h scheduler.h
  group stdLib
    ../lib/stdPeriph/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c misc.c
    ../lib/stdPeriph/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_tim.h misc.h
